# Keil uVision project 5220-apm32.uvprojx, settings and files
target 5220-amp32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F103TB Geehy
  pack: Geehy.APM32F1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 5220-apm32 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: APM32F10X_HD
  c misc: --gnu
  c include: ..\CMSIS;..\FWLib\inc;..\User\Main;..\User\System;..\User\Handware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/arm/: startup_apm32f103xb.s
  group FWLib
    ../FWLib/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_eth.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_usb.c apm32f10x_usb_device.c apm32f10x_usb_host.c apm32f10x_wwdt.c
  group Main
    ../User/Main/: apm32f10x_int.c main.c system_apm32f10x.c apm32f10c_conf.h
  group System
    ../User/System/: Rcm.c Rcm.h
  group Handware
    ../User/Handware/: uart.c uart.h 485.c 485.h spi.c spi.h ktm52.c ktm52.h I2C.c I2C.h gt24c64a.c gt24c64a.h
